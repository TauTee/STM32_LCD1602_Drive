# Keil uVision project gpio.uvprojx, settings and files
target Gpio (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gpio +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\MainFile;..\stdPeriphDriveLib\inc;..\HardWare;..\HardWare\cycle_buffer
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ARM
    ../ARM/: startup_stm32f10x_md.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group MainFile
    ../MainFile/: main.c
  group stdPeriphDriveLib
    ../stdPeriphDriveLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HardWare
    ../HardWare/: LCD.c sys.c esp8266_at.c UART2_DMA.c
    ../HardWare/cycle_buffer/: cycle_buffer_io.c
software components: RTOS:kernel 3.1.3, RTOS:shell 3.1.3
